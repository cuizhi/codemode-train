# Keil uVision project test2a.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test2a +hex
  c flags: Optim=1
  c include: ..\CORE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\usart;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group users
    ./: startup_stm32f10x_hd.s main.c stm32f10x_it.c system_stm32f10x.c
  group sys
    ../SYSTEM/sys/: sys.c
  group hardware
    ../HARDWARE/LED/: led.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/KEY/: key.c
  group stm32_FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group m3_core
    ../CORE/: core_cm3.c
