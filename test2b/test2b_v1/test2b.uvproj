# Keil uVision project test2b.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test2b +hex
  c flags: Optim=1
  c include: .\hardware\inc;.\m3_core;.\STM32F10x_FWLib\inc;.\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/src/: stm32f10x_it.c system_stm32f10x.c
    ./: main.c
  group HARDWARE
    ./hardware/src/: key.c led.c sys.c usart.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group m3_core
    ./m3_core/: core_cm3.c startup_stm32f10x_hd.s
